FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://eco-audio.cfg"
